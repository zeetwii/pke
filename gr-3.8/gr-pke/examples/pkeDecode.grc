options:
  parameters:
    author: ZeeTulsa
    description: Flowgraph tha transmits PKE messages
    generate_options: qt_gui
    id: pkeTransmit
    output_language: python
    title: PKE Transmit
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 'msg_freq + offset_freq '
  states: {}
- name: decodeMul
  id: variable
  parameters:
    value: '4'
  states: {}
- name: msg_freq
  id: variable
  parameters:
    value: '-134e3'
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: pulse_size
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: rate_mul
  id: variable
  parameters:
    value: pulse_size / (1/samp_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(int(rate_mul) / decodeMul)
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '1'
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.015'
    init: '0'
    low: '.015'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pke_pkeDecoder_0
  id: pke_pkeDecoder
  parameters:
    ipAddr: 0.0.0.0
    multiplier: decodeMul
    portNum: '7331'
  states: {}
- name: pke_pkeGenerator_0
  id: pke_pkeGenerator
  parameters:
    ipAddr: 0.0.0.0
    multiplier: round(rate_mul)
    portNum: '7331'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_throttle_0, '0']
- [blocks_rms_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_threshold_ff_0, '0', pke_pkeDecoder_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', blocks_rms_xx_0, '0']
- [pke_pkeGenerator_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
