options:
  parameters:
    author: ZeeTulsa
    description: Record and decode the PKE Signal from cars
    generate_options: qt_gui
    id: pkeDecode
    output_language: python
    title: PKE Decoder
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 134e3
  states: {}
- name: offsetFreq
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/zee/rf/captures/lowSpeed/24kHzNoKeyStart.complex
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_peak_detector_xb_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: '10'
    threshold_factor_fall: '0.40'
    threshold_factor_rise: '0.25'
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '1'
    type: complex
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.1'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: correctiq_correctiq_0
  id: correctiq_correctiq
  parameters: {}
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: byte
    update_time: '0.0010'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_complex_to_float_0, '0', blocks_threshold_ff_0, '0']
- [blocks_file_source_0, '0', correctiq_correctiq_0, '0']
- [blocks_peak_detector_xb_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_peak_detector_xb_0, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_rms_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [correctiq_correctiq_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
