options:
  parameters:
    author: ZeeTulsa
    description: Flowgraph tha transmits PKE messages
    generate_options: qt_gui
    id: pkeTransmit
    output_language: python
    title: PKE Transmit
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 'msg_freq + offset_freq '
  states: {}
- name: msg_freq
  id: variable
  parameters:
    value: '-134e3'
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: pulse_size
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: rate_mul
  id: variable
  parameters:
    value: pulse_size / (1/samp_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: temp
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zee/rf/captures/sample.cfile
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '4'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '100'
    freq0: center_freq
    gain0: '100'
    if_gain0: '100'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pke_pkeGenerator_0
  id: pke_pkeGenerator
  parameters:
    ipAddr: 0.0.0.0
    multiplier: round(rate_mul)
    portNum: '7331'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [pke_pkeGenerator_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
