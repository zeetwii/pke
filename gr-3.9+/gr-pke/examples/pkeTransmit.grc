options:
  parameters:
    author: ZeeTulsa
    generate_options: no_gui
    id: pke_transmit
    output_language: python
    title: PKE Transmit
  states: {}

blocks:
- name: bit_period
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: msg_freq + offset_freq
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {state: disabled}
- name: msg_freq
  id: variable
  parameters:
    value: 134e3
  states: {}
- name: offset_freq
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: rate_mul
  id: variable
  parameters:
    value: samp_rate / (1/bit_period)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zee/rf/captures/tx.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/zee/rf/captures/test.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/zee/rf/captures/rx.cfile
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: pke_pkeGenerator_0
  id: pke_pkeGenerator
  parameters:
    ipAddr: 0.0.0.0
    multiplier: int(rate_mul)
    portNum: '7331'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: '14'
    center_freq: center_freq
    dev_args: hackrf=0
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: '14'
    center_freq: 315e6
    dev_args: hackrf=0
    gain: '32'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8080'
  states: {}

connections:
- [analog_sig_source_x_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [pke_pkeGenerator_0, '0', blocks_float_to_complex_0, '0']
- [soapy_hackrf_source_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1
