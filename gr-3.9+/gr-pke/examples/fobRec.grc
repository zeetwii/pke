options:
  parameters:
    author: ZeeTulsa
    generate_options: no_gui
    id: key_fob_rec
    output_language: python
    title: Key Fob Alert
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/zee/rf/captures/fob.cfile
    type: complex
  states: {}
- name: blocks_peak_detector2_fb_0
  id: blocks_peak_detector2_fb
  parameters:
    alpha: '0.001'
    look_ahead: '1000'
    threshold_factor_rise: '7'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '7332'
    send_eof: 'False'
    type: byte
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    gain: '20'
    samp_rate: samp_rate
    type: fc32
    vga: '30'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8090'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_peak_detector2_fb_0, '0']
- [blocks_peak_detector2_fb_0, '0', network_udp_sink_0, '0']
- [soapy_hackrf_source_0, '0', blocks_complex_to_float_0, '0']
- [soapy_hackrf_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
